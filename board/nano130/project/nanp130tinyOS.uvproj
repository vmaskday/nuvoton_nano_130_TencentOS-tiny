# Keil uVision project nanp130tinyOS.uvproj, settings and files
target nano130TinyOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NANO130KE3BN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(42000000) CPUTYPE("Cortex-M0")
  output: nanp130tinyOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\inc;..\StdDriver\inc;..\TOS_CONFIG;..\..\..\arch\arm\arm-v6m\common\include;..\..\..\arch\arm\arm-v6m\cortex-m0\armcc;..\..\..\kernel\core\include;..\..\..\kernel\pm\include;..\..\..\osal\cmsis_os
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Deive
    ../src/: startup_Nano100Series.s
  group Board
    ../src/: system_Nano100Series.c nano130clock.c main.c
    ../TOS_CONFIG/: tos_config.h
    ../src/tickless/: bsp_pwr_mgr.c bsp_pm_device.c bsp_tickless_alarm.c
  group StdDriver
    ../StdDriver/src/: clk.c sys.c uart.c retarget.c gpio.c
  group TinyOS_ARCH
    ../../../arch/arm/arm-v6m/cortex-m0/armcc/: port_c.c port_s.S
    ../../../arch/arm/arm-v6m/common/: tos_cpu.c tos_fault.c
  group TOS_Kernel
    ../../../kernel/core/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
    ../../../kernel/pm/: tos_pm.c tos_tickless.c
  group CMSIS_OS
    ../../../osal/cmsis_os/: cmsis_os.c
